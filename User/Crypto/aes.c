#include "aes.h"

// 轮密钥数组
uint32_t w[Nb * (Nr + 1)]; // 存储扩展后的轮密钥

// 轮常量数组
uint32_t rcon[10] = {
    0x01000000, 0x02000000, 0x04000000, 0x08000000, 0x10000000,
    0x20000000, 0x40000000, 0x80000000, 0x1B000000, 0x36000000}; // Rcon 数组用于轮密钥扩展中的常量

// AES 加密 S-Box
uint8_t sbox[16 * 16] = {
    // AES 加密使用的 S-Box 表
    /*      0     1     2     3     4     5     6     7     8     9     a     b     c     d     e     f */
    /*0*/ 0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab, 0x76,
    /*1*/ 0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4, 0x72, 0xc0,
    /*2*/ 0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71, 0xd8, 0x31, 0x15,
    /*3*/ 0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2, 0xeb, 0x27, 0xb2, 0x75,
    /*4*/ 0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6, 0xb3, 0x29, 0xe3, 0x2f, 0x84,
    /*5*/ 0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb, 0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf,
    /*6*/ 0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45, 0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8,
    /*7*/ 0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5, 0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2,
    /*8*/ 0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44, 0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73,
    /*9*/ 0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a, 0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb,
    /*a*/ 0xe0, 0x32, 0x3a, 0x0a, 0x49, 0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79,
    /*b*/ 0xe7, 0xc8, 0x37, 0x6d, 0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08,
    /*c*/ 0xba, 0x78, 0x25, 0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a,
    /*d*/ 0x70, 0x3e, 0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e,
    /*e*/ 0xe1, 0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
    /*f*/ 0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb, 0x16};

// AES 解密 Inverse S-Box
uint8_t inv_sbox[16 * 16] = {
    // AES 解密使用的逆 S-Box 表
    /*      0     1     2     3     4     5     6     7     8     9     a     b     c     d     e     f */
    /*0*/ 0x52, 0x09, 0x6a, 0xd5, 0x30, 0x36, 0xa5, 0x38, 0xbf, 0x40, 0xa3, 0x9e, 0x81, 0xf3, 0xd7, 0xfb,
    /*1*/ 0x7c, 0xe3, 0x39, 0x82, 0x9b, 0x2f, 0xff, 0x87, 0x34, 0x8e, 0x43, 0x44, 0xc4, 0xde, 0xe9, 0xcb,
    /*2*/ 0x54, 0x7b, 0x94, 0x32, 0xa6, 0xc2, 0x23, 0x3d, 0xee, 0x4c, 0x95, 0x0b, 0x42, 0xfa, 0xc3, 0x4e,
    /*3*/ 0x08, 0x2e, 0xa1, 0x66, 0x28, 0xd9, 0x24, 0xb2, 0x76, 0x5b, 0xa2, 0x49, 0x6d, 0x8b, 0xd1, 0x25,
    /*4*/ 0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92,
    /*5*/ 0x6c, 0x70, 0x48, 0x50, 0xfd, 0xed, 0xb9, 0xda, 0x5e, 0x15, 0x46, 0x57, 0xa7, 0x8d, 0x9d, 0x84,
    /*6*/ 0x90, 0xd8, 0xab, 0x00, 0x8c, 0xbc, 0xd3, 0x0a, 0xf7, 0xe4, 0x58, 0x05, 0xb8, 0xb3, 0x45, 0x06,
    /*7*/ 0xd0, 0x2c, 0x1e, 0x8f, 0xca, 0x3f, 0x0f, 0x02, 0xc1, 0xaf, 0xbd, 0x03, 0x01, 0x13, 0x8a, 0x6b,
    /*8*/ 0x3a, 0x91, 0x11, 0x41, 0x4f, 0x67, 0xdc, 0xea, 0x97, 0xf2, 0xcf, 0xce, 0xf0, 0xb4, 0xe6, 0x73,
    /*9*/ 0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e,
    /*a*/ 0x47, 0xf1, 0x1a, 0x71, 0x1d, 0x29, 0xc5, 0x89, 0x6f, 0xb7, 0x62, 0x0e, 0xaa, 0x18, 0xbe, 0x1b,
    /*b*/ 0xfc, 0x56, 0x3e, 0x4b, 0xc6, 0xd2, 0x79, 0x20, 0x9a, 0xdb, 0xc0, 0xfe, 0x78, 0xcd, 0x5a, 0xf4,
    /*c*/ 0x1f, 0xdd, 0xa8, 0x33, 0x88, 0x07, 0xc7, 0x31, 0xb1, 0x12, 0x10, 0x59, 0x27, 0x80, 0xec, 0x5f,
    /*d*/ 0x60, 0x51, 0x7f, 0xa9, 0x19, 0xb5, 0x4a, 0x0d, 0x2d, 0xe5, 0x7a, 0x9f, 0x93, 0xc9, 0x9c, 0xef,
    /*e*/ 0xa0, 0xe0, 0x3b, 0x4d, 0xae, 0x2a, 0xf5, 0xb0, 0xc8, 0xeb, 0xbb, 0x3c, 0x83, 0x53, 0x99, 0x61,
    /*f*/ 0x17, 0x2b, 0x04, 0x7e, 0xba, 0x77, 0xd6, 0x26, 0xe1, 0x69, 0x14, 0x63, 0x55, 0x21, 0x0c, 0x7d};

// 循环左移一个32位字
uint32_t rot_word(uint32_t word)
{
    return (word << 8) | (word >> 24);
}

// 使用S盒替换一个32位字
uint32_t sub_word(uint32_t word)
{
    uint8_t b0, b1, b2, b3;

    b0 = (uint8_t)(word & 0xFF);
    b1 = (uint8_t)((word >> 8) & 0xFF);
    b2 = (uint8_t)((word >> 16) & 0xFF);
    b3 = (uint8_t)((word >> 24) & 0xFF);

    b0 = sbox[b0];
    b1 = sbox[b1];
    b2 = sbox[b2];
    b3 = sbox[b3];

    return ((uint32_t)b3 << 24) |
           ((uint32_t)b2 << 16) |
           ((uint32_t)b1 << 8) |
           (uint32_t)b0;
}

// GF(2^8)域乘法
uint8_t gf_mul(uint8_t a, uint8_t b)
{
    uint8_t i;
    uint8_t p = 0;
    uint8_t hi_bit_set;

    for (i = 0; i < 8; i++)
    {
        if (b & 1)
        {
            p ^= a;
        }
        hi_bit_set = a & 0x80;
        a <<= 1;
        if (hi_bit_set)
        {
            a ^= 0x1B;
        }
        b >>= 1;
    }
    return p;
}

// 密钥扩展
void aes_keyexpansion(uint8_t *key)
{
    uint8_t i;
    uint32_t temp;

    // 复制初始密钥
    for (i = 0; i < Nk; i++)
    {
        w[i] = ((uint32_t)key[4 * i] << 24) |
               ((uint32_t)key[4 * i + 1] << 16) |
               ((uint32_t)key[4 * i + 2] << 8) |
               ((uint32_t)key[4 * i + 3]);
    }

    // 生成扩展密钥
    for (i = Nk; i < Nb * (Nr + 1); i++)
    {
        temp = w[i - 1];
        if (i % Nk == 0)
        {
            // 每 Nk 个字后进行特殊处理：循环左移、S-Box 替换和 XOR Rcon
            temp = rot_word(temp);
            temp = sub_word(temp);
            temp ^= rcon[i / Nk - 1];
        }
        else if (Nk > 6 && i % Nk == 4)
        {
            // 对于Nk大于6的密钥并且当 i % Nk == 4时仅进行 S-Box 替换
            temp = sub_word(temp);
        }
        w[i] = w[i - Nk] ^ temp;
    }
}

// 轮密钥加
void add_roundkey(uint8_t state[4][Nb], uint8_t round)
{
    uint8_t i;
    uint32_t temp;

    for (i = 0; i < Nb; i++)
    {
        temp = w[round * Nb + i];
        state[0][i] ^= (uint8_t)(temp >> 24);
        state[1][i] ^= (uint8_t)(temp >> 16);
        state[2][i] ^= (uint8_t)(temp >> 8);
        state[3][i] ^= (uint8_t)temp;
    }
}

// 字节替换
void sub_state(uint8_t state[4][Nb])
{
    uint8_t i, j;

    for (i = 0; i < 4; i++)
    {
        for (j = 0; j < Nb; j++)
        {
            state[i][j] = sbox[state[i][j]];
        }
    }
}

// 字节替换
void shift_rows(uint8_t state[4][Nb])
{
    uint8_t row, shift, col;
    uint8_t temp;

    for (row = 1; row < 4; row++)
    {
        for (shift = 0; shift < row; shift++)
        {
            temp = state[row][0];
            for (col = 0; col < Nb - 1; col++)
            {
                state[row][col] = state[row][col + 1];
            }
            state[row][Nb - 1] = temp;
        }
    }
}

// 列混淆
void mix_columns(uint8_t state[4][Nb])
{
    uint8_t col;
    uint8_t a, b, c, d;

    for (col = 0; col < Nb; col++)
    {
        a = state[0][col];
        b = state[1][col];
        c = state[2][col];
        d = state[3][col];

        state[0][col] = (uint8_t)gf_mul(0x02, a) ^ gf_mul(0x03, b) ^ c ^ d;
        state[1][col] = a ^ (uint8_t)gf_mul(0x02, b) ^ gf_mul(0x03, c) ^ d;
        state[2][col] = a ^ b ^ (uint8_t)gf_mul(0x02, c) ^ gf_mul(0x03, d);
        state[3][col] = (uint8_t)gf_mul(0x03, a) ^ b ^ c ^ (uint8_t)gf_mul(0x02, d);
    }
}

// AES加密
void aes_encrypt(uint8_t *input, uint8_t *output)
{
    uint8_t state[4][Nb];
    uint8_t i, j;
    uint8_t round;

    // 加载数据到状态矩阵
    for (i = 0; i < Nb; i++)
    {
        for (j = 0; j < 4; j++)
        {
            state[j][i] = input[i * 4 + j];
        }
    }

    // 初始轮密钥加
    add_roundkey(state, 0);

    // 中间轮：SubBytes -> ShiftRows -> MixColumns -> AddRoundKey
    for (round = 1; round <= Nr - 1; round++)
    {
        sub_state(state);
        shift_rows(state);
        mix_columns(state);
        add_roundkey(state, round);
    }

    // 最终轮：SubBytes -> ShiftRows -> AddRoundKey
    sub_state(state);
    shift_rows(state);
    add_roundkey(state, Nr);

    // 输出结果
    for (i = 0; i < 4; i++)
    {
        for (j = 0; j < Nb; j++)
        {
            output[i + 4 * j] = state[i][j];
        }
    }
}

// 逆字节替换
void inv_sub_state(uint8_t state[4][Nb])
{
    uint8_t i, j;

    for (i = 0; i < 4; i++)
    {
        for (j = 0; j < Nb; j++)
        {
            state[i][j] = inv_sbox[state[i][j]];
        }
    }
}

// 逆行移位
void inv_shift_rows(uint8_t state[4][Nb])
{
    uint8_t row, shift, col;
    uint8_t temp;

    for (row = 1; row < 4; row++)
    {
        for (shift = 0; shift < row; shift++)
        {
            temp = state[row][Nb - 1];
            for (col = Nb - 1; col > 0; col--)
            {
                state[row][col] = state[row][col - 1];
            }
            state[row][0] = temp;
        }
    }
}

// 逆列混淆
void inv_mix_columns(uint8_t state[4][Nb])
{
    uint8_t col;
    uint8_t a, b, c, d;

    for (col = 0; col < Nb; col++)
    {
        a = state[0][col];
        b = state[1][col];
        c = state[2][col];
        d = state[3][col];

        state[0][col] = (uint8_t)gf_mul(0x0e, a) ^ gf_mul(0x0b, b) ^ gf_mul(0x0d, c) ^ gf_mul(0x09, d);
        state[1][col] = (uint8_t)gf_mul(0x09, a) ^ gf_mul(0x0e, b) ^ gf_mul(0x0b, c) ^ gf_mul(0x0d, d);
        state[2][col] = (uint8_t)gf_mul(0x0d, a) ^ gf_mul(0x09, b) ^ gf_mul(0x0e, c) ^ gf_mul(0x0b, d);
        state[3][col] = (uint8_t)gf_mul(0x0b, a) ^ gf_mul(0x0d, b) ^ gf_mul(0x09, c) ^ gf_mul(0x0e, d);
    }
}

// AES解密
void aes_decrypt(uint8_t *input, uint8_t *output)
{
    uint8_t state[4][Nb];
    uint8_t i, j;
    uint8_t round;

    // 加载数据到状态矩阵
    for (i = 0; i < Nb; i++)
    {
        for (j = 0; j < 4; j++)
        {
            state[j][i] = input[i * 4 + j];
        }
    }

    // 初始轮：添加最终轮密钥
    add_roundkey(state, Nr);

    // 中间轮：InvShiftRows -> InvSubBytes -> AddRoundKey -> InvMixColumns
    for (round = Nr - 1; round >= 1; round--)
    {
        inv_shift_rows(state);
        inv_sub_state(state);
        add_roundkey(state, round);
        inv_mix_columns(state);
    }

    // 最终轮：InvShiftRows -> InvSubBytes -> AddRoundKey
    inv_shift_rows(state);
    inv_sub_state(state);
    add_roundkey(state, 0);

    // 输出结果
    for (i = 0; i < 4; i++)
    {
        for (j = 0; j < Nb; j++)
        {
            output[i + 4 * j] = state[i][j];
        }
    }
}
