# Keil uVision project STC8H8K64U.uvproj, settings and files
target STC8H8K64U (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: STC8H8K64U +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\TOP;..\User\CRYPTO;..\User\UART;..\User\Peripheral
  group Top
    ../User/Top/: main.c tools.c tools.h
  group Crypto
    ../User/Crypto/: aes.c aes.h milenage.c milenage.h
  group Uart
    ../User/Uart/: ringBuffer.c ringBuffer.h uartRingBuffer.c uartRingBuffer.h uartRingBuffer_cfg.h
